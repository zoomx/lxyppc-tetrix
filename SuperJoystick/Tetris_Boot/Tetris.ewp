# IAR project Tetris.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: inc; ..\UsbLib\inc; ..\FWLib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration RAM_DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_RAM; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\library\inc; ..\..\..\..\..\FWLib\library\inc
  XLINK.XclFile: lnkarm_ram.xcl
configuration SIM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STM3210B_EVAL
configuration JOYSTICK (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: VECT_TAB_FLASH; JOYSTICK; _STM32_
  ICCARM.CCIncludePath2: inc; ..\UsbLib\inc; ..\FWLib\inc; ..\GraphicLib\inc
configuration JOYSTICK_HEX (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: VECT_TAB_FLASH; JOYSTICK; _STM32_
  ICCARM.CCIncludePath2: as above
  group Application files
    source/: DrawText.c font.c HidDevice.c hw_config.c JoyMouseProc.c KeyboardProc.c main.c SendImage.c SettingProc.c SSD1303.c stm32f10x_it.c StringResource.c Task.c TaskSwitchIsr.s Tetris.c TetrisProc.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWlib
    ../FWLib/src/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group USBLib
    ../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
