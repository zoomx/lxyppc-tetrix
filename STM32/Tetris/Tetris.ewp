# IAR project Tetris.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: inc; ..\UsbLib\inc; ..\FWLib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\library\inc; ..\..\..\..\..\FWLib\library\inc
configuration RAM_DEBUG (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_RAM; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: as above
  XLINK.XclFile: lnkarm_ram.xcl
configuration HEX (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  group Application files
    source/: hw_config.c main.c SendImage.c stm32f10x_it.c TaskSwitchIsr.s usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group EWARM
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWlib
    ../FWLib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group USBLib
    ../USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
