# Keil uVision project bldc.uvproj, settings and files
target HSI_48MHz (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: bldc +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX, USE_STM320518_EVAL, USE_DEFAULT_TIMEOUT_CALLBACK
  c include: .\;.\lib\CMSIS\Device\ST\STM32F0xx\Include;.\lib\STM32F0xx_StdPeriph_Driver\inc;.\lib\STM32F0xx_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./: stm32f0xx_it.c main.c data_process.c stm32f0xx_i2c_cpal_usercallback.c
  group StdPeriph_Driver
    ./lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ./: system_stm32f0xx_HSI_48Mhz.c
  group MDK-ARM
    ./lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group Doc
    ./STM320518/: bldc.map
  group CPAL_Driver
    ./lib/STM32F0xx_CPAL_Driver/src/: stm32f0xx_i2c_cpal_hal.c stm32f0xx_i2c_cpal.c
  group script
    ./: bldcviewer.lua
