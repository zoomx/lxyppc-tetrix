# Keil uVision project dr_dot.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dr_dot +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=24000000
  c include: .;.\bsp;..\..\drivers\24l01;..\..\drivers\sensors;..\..\drivers\data_link;..\..\library\CMSIS\Device\ST\STM32F10x;..\..\library\CMSIS\Include;..\..\library\STM32F10x_StdPeriph_Driver\inc;..\..\algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c
    ../../drivers/data_link/: ring_buffer.c uart_data_process.c
  group System
    ./: system_stm32f10x_HSE_16MHz_sys_72MHz.c
    ../../library/CMSIS/Device/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Drivers
    ../../drivers/24l01/: nrf24l01.c
    ../../drivers/sensors/: mpu6050.c hmc5883.c
  group bsp
    ./bsp/: bsp.c gpio.c i2c.c pwm.c spi.c uart.c adc.c sensors.c
  group library
    ../../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_usart.c
  group algorithm
    ../../algorithm/: alg_setup.c MargAHRS.c
