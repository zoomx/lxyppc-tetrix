# Keil uVision project main.uvproj, settings and files
target ctrl (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")ESEL ELITTLE FPU2
  output: ctrl +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .;.\bsp;..\..\library\STM32F30x_StdPeriph_Driver\inc;..\..\library\STM32_USB-FS-Device_Driver\inc;..\..\library\CMSIS\Device\ST\STM32F30x\Include;..\..\drivers\usb_hid\stm32_fs;..\..\drivers\data_link;..\..\drivers\sensors;..\..\drivers\24l01;..\..\algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MDK-ARM
    ../../library/CMSIS/Device/ST/STM32F30x/Source/arm/: startup_stm32f30x.s
  group STM32_USB-FS-Device_Driver
    ../../library/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group bsp
    ./bsp/: spi.c gpio.c bsp.c i2c.c pwm.c
  group User
    ./: hw_config.c main.c system_stm32f30x_bypass_8MHz_sys_72MHz.c stm32f30x_it.c
    ../../drivers/data_link/: ring_buffer.c
  group usb_hid
    ../../drivers/usb_hid/stm32_fs/: usb_desc.c usb_endp.c usb_istr.c usb_pwr.c usb_prop.c
  group STM32F30x_StdPeriph_Driver
    ../../library/STM32F30x_StdPeriph_Driver/src/: stm32f30x_wwdg.c stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group driver
    ../../drivers/sensors/: lsm303dlhc.c l3gd20.c
    ../../drivers/24l01/: nrf24l01.c
  group algorithm
    ../../algorithm/: MargAHRS.c alg_setup.c
