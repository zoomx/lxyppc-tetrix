# Keil uVision project I2C.uvproj, settings and files
target I2C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: BLDC_TESTER +hex
  c flags: Optim=1
  c define: USE_STM3210C_EVAL
  c include: .\Source\App;.\Source\CMSIS\Core\CM3;.\Source\CMSIS\Core\CM3\startup\arm;.\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\STM32F10x_StdPeriph_Driver\src;.\Source\STM32_USB_Device_Library\Core\inc;.\Source\STM32_USB_Device_Library\Class\hid\inc;.\Source\STM32_USB_OTG_Driver\inc;.\Source\bsp;.\Source\driver;.\Source;..\drivers\nrf24l01\inc;..\drivers\nrf24l01\src\esb;..\drivers\nrf24l01\example
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./Source/App/: GLCD.c main.c stm32f10x_it.c i2c_ee.c ring_buffer.c USART.c usb_bsp.c usbd_desc.c usbd_usr.c
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group LIB
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_spi.c
  group USB
    ./Source/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Source/App/: usb_hid_core.c
  group USB Driver
    ./Source/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_dcd.c usb_core.c
  group bsp
    ./Source/bsp/: gpio.c spi.c bsp.c
  group driver
    ./Source/driver/: nrf24l01.c
    ../drivers/nrf24l01/src/: hal_nrf_l01.c
    ../drivers/nrf24l01/src/esb/: radio_esb.c
