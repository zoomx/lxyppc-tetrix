# Keil uVision project Project.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32 +hex
  c flags: OneElfS=1 wLevel=2
  c include: .;..;..\..\sw\airborne;..\..\sw\airborne\arch;..\..\sw\airborne\arch\stm32;..\..\sw\airborne\firmwares\rotorcraft;..\..\sw\include;..\..\sw\airborne\mcu_periph;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group firmware
    ../../sw/airborne/firmwares/rotorcraft/: commands.c main.c autopilot.c datalink.c telemetry.c navigation.c stabilization.c
  group firmware_stabilization
    ../../sw/airborne/firmwares/rotorcraft/stabilization/: stabilization_none.c stabilization_rate.c stabilization_attitude_ref_quat_int.c stabilization_attitude_quat_int.c
  group firmware_guidance
    ../../sw/airborne/firmwares/rotorcraft/guidance/: guidance_h.c guidance_v.c
  group firmware_actuator
    ../../sw/airborne/firmwares/rotorcraft/actuators/: supervision.c actuators_pwm_supervision.c
    ../../sw/airborne/firmwares/rotorcraft/actuators/arch/stm32/: actuators_pwm_arch.c
  group airborne
    ../../sw/airborne/: mcu.c
  group math
    ../../sw/airborne/math/: pprz_geodetic_double.c pprz_geodetic_float.c pprz_geodetic_int.c pprz_trig_int.c
  group arch_stm32
    ../../sw/airborne/arch/stm32/: mcu_arch.c led_hw.c stm32_vector_table.c stm32_exceptions.c
  group arch_stm32_mcu_periph
    ../../sw/airborne/arch/stm32/mcu_periph/: spi_arch.c sys_time_arch.c uart_arch.c adc_arch.c i2c_arch.c
  group arch_stm32_subsystems
    ../../sw/airborne/arch/stm32/subsystems/: settings_arch.c
    ../../sw/airborne/arch/stm32/subsystems/radio_control/: spektrum_arch.c
  group mcu_periph
    ../../sw/airborne/mcu_periph/: uart.c i2c.c spi.c sys_time.c
  group subsystems
    ../../sw/airborne/subsystems/: ahrs.c electrical.c gps.c imu.c ins.c radio_control.c settings.c
  group subsystems_ahrs
    ../../sw/airborne/subsystems/ahrs/: ahrs_int_cmpl_quat.c ahrs_aligner.c
  group subsystems_gps
    ../../sw/airborne/subsystems/gps/: gps_ubx.c
  group subsystems_imu
    ../../sw/airborne/subsystems/imu/: imu_aspirin2.c
  group subsystems_datalink
    ../../sw/airborne/subsystems/datalink/: downlink.c pprz_transport.c
  group subsystems_navigation
    ../../sw/airborne/subsystems/navigation/: common_flight_plan.c
  group subsystems_ins
    ../../sw/airborne/subsystems/ins/: vf_float.c
