# Keil uVision project Smpl_DrvSPI.uvproj, settings and files
target Smpl_DrvSPI (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Smpl_DrvSPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\;.\lib\CMSIS\CM0\CoreSupport;.\lib\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;.\lib\Include;.\lib\Include\Driver;.\bsp;.\drv
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./lib/CMSIS/CM0/CoreSupport/: core_cm0.c
    ./lib/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
    ./lib/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
  group Source files
    ./: Smpl_DrvSPI.c
  group Library files
    ./lib/Src/Driver/: DrvSPI.c DrvSYS.c DrvUART.c retarget.c DrvGPIO.c DrvPDMA.c
  group bsp
    ./bsp/: spi.c bsp.c gpio.c
  group drv
    ./drv/: drv_nrf24l01.c
